# Keil uVision project main.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: main +hex
  c flags: Optim=1
  c include: ..\SYS;..\device\MMC_SD;..\device\SPI2;..\device\VS1003;..\main;..\device\LCD13164;..\FAT;..\Untogb;..\device\Keyboard;..\Lib;..\GUI;..\FFT;..\device\ADC;..\game;..\Lib\STM32F10x
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: STM32F10x.s
  group main
    ./: main.c
  group sys
    ../SYS/: SYS.C DELAY.C
    ../Lib/: STM32F10xR.LIB
  group device
    ../device/SPI2/: SPI2.C
    ../device/VS1003/: VS1003x.c
    ../device/MMC_SD/: MMC_SD.C
    ../device/LCD13164/: LCD13164.C
    ../device/Keyboard/: keyboard.c
    ../device/ADC/: ADC.C
  group FAT
    ../FAT/: FAT.c
    ../Untogb/: untogb.c
  group GUI
    ../GUI/: gui.c mp3player.c lrcpro.c
  group FFT
    ../FFT/: my_fft.c
  group game
    ../game/: snake.c russia.c
