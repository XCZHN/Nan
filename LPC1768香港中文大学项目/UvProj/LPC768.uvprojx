# Keil uVision project LPC768.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ZY-2017-CUHK +hex
  AfterMake: fromelf.exe --bin ".\Objects\@L.axf" --output "..\Objects\@L.bin"
  c flags: Optim=1 wLevel=2
  c include: ..\SourceCode;..\SourceCode\CMSIS\CM3;..\SourceCode\CMSIS\LPC17xx;..\SourceCode\Drv;..\SourceCode\Mid;..\SourceCode\Lib;..\SourceCode\App;..\SourceCode\Desktop;..\SourceCode\ICON;..\SourceCode\STM32F10x
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group CMSIS
    ../SourceCode/CMSIS/CM3/: core_cm3.c
    ../SourceCode/CMSIS/LPC17xx/: system_LPC17xx.c
    ../SourceCode/CMSIS/LPC17xx/Startup/: startup_LPC17xx.s
  group Drv
    ../SourceCode/Drv/: drv_eeprom.o drv_enc28j60.o drv_flash.o drv_keyboard.o drv_otherext.o drv_rtc.o drv_spi.o drv_timer.o drv_wdt.o Drv_LCD.c Drv_Uart.c Drv_Voice.c Drv_74HC16X.c Drv_RFM.c Drv_Wiegand.c
  group Lib
    ../SourceCode/Lib/: Lib_Public.c
  group Mid
    ../SourceCode/Mid/: Mid_SysTick.c Mid_Magically.c Mid_SysConfig.c Mid_Comm.c Mid_Lockers.c Mid_ZiKu.c
  group App
    ../SourceCode/App/: App_main.c App_ComDeal.c App_Record.c App_Card.c App_Network.c App_GUI.c App_KeyUI.c app_Lockers.c app_Fingerprint.c
  group Doc
    ../SourceCode/Doc/: ReadMe.txt
software components: CMSIS:CORE 5.1.1
